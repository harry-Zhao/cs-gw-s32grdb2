FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += " \ 
        file://0001-Add-led-rgb-and-eirq-node-to-dts.patch \
	"
