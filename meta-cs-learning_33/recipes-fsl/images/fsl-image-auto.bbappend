IMAGE_INSTALL_append_s32 += " \
	ledAPP \
	s32grdb2-dtsled \
	s32grdb2-eirq \
"
