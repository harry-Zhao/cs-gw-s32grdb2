IMAGE_INSTALL_append_s32 += " \
    ledAPP \
    s32grdb2-gpio-rgb \
"
